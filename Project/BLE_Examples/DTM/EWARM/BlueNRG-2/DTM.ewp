# IAR project DTM.ewp, settings and files
configuration UART (ARM)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: UART_INTERFACE; WATCHDOG; WATCHDOG_TIME=1; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1; BLUENRG_TILE
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\hal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTM_UART.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART.bin"
  ILINK.IlinkOutputFile: DTM_UART.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Hal
    ../../../../../Library/hal/src/: context_switch.s fifo.c miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_dle_api_stubs.c stack_priv_api_stubs.c stack_sc_api_stubs.c stack_slvonly_api_stubs.c stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c cmd.c DTM_boot.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c transport_layer.c
